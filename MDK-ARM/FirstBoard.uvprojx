# Keil uVision project FirstBoard.uvprojx, settings and files
target FirstBoard (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: FirstBoard
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;                ../Drivers/STM32F0xx_HAL_Driver/Inc;                ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_spi.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_flash.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c dwm1000.c
    ../Inc/: dwm1000.h
software components: CMSIS:CORE 5.0.1, Compiler:Event Recorder 1.1.0, Compiler:I/O:STDOUT 1.2.0
